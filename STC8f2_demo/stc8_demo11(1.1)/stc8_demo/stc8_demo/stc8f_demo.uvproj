# Keil uVision project stc8f_demo.uvproj, settings and files
target project (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: stc8f_demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: STARTUP.A51 Lensdrv.c main.c spi.c timer.c uart.c EEPROM.c
